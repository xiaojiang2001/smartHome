# Keil uVision project USART.uvprojx, settings and files
target USART (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\NET\device\inc;..\NET\MQTT;..\NET\onenet\inc;..\HARDWARE\RC522;..\HARDWARE\SPI;..\HARDWARE\BEEP;..\SYSTEM\timer;..\HARDWARE\BH1750;..\HARDWARE\DHT11;..\HARDWARE\BEEP;..\SYSTEM\EXTI;..\HARDWARE\KEY;..\SYSTEM\ADC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RC522/: RC522.c
    ../HARDWARE/SPI/: spi_driver.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/timer/: tim.c
    ../SYSTEM/EXTI/: exti.c
    ../SYSTEM/ADC/: adc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_adc.c
  group OneNET
    ../NET/onenet/src/: onenet.c
  group net_protocol
    ../NET/MQTT/: MqttKit.c
  group net_device
    ../NET/device/src/: m5310.c
  group README
    ../: README.TXT
